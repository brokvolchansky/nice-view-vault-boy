## boards/shields/nice_view_vault_boy/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_VAULT_BOY
    def_bool $(shields_list_contains,nice_view_vault_boy)
```
